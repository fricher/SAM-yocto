LINUX_VERSION = "4.19.71"

SRCREV = "e2e9cec6fb061ba58304fd391ef76747f2963557"

#CMDLINE = "dwc_otg.lpm_enable=1 ${SERIAL} root=/dev/mmcblk0p2 rootfstype=ext4 rootwait"

